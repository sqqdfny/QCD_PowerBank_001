# Keil uVision project Project.uvproj, settings and files
target DEBUG (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: debug +hex
  AfterMake: _build_debug_out.bat
  c flags: SizeSpeed=1
  c define: DEBUG
  c include: .\inc
  group src
    ./: STARTUP.A51
    ./src/: main.c delay.c display.c normal.c key.c tp5602.c standby.c adc.c
  group inc
    ./inc/: adc.h delay.h display.h Function_Define.h key.h main.h N76E003.h normal.h SFR_Macro.h standby.h tp5602.h typedef.h
target release (MCS-51)
  device: N76E003 Nuvoton
  cpu: as above
  output: release +hex
  AfterMake: _build_release_out.bat
  c flags: SizeSpeed=1
  c include: .\inc
